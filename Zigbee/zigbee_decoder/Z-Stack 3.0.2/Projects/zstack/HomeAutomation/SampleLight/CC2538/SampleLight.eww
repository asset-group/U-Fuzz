<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleLight.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SampleLight</project>
        <configuration>Coordinator</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>Router</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>EndDevice</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



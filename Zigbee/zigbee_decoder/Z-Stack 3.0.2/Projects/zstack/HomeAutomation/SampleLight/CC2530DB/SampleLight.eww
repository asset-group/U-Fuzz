<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleLight.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SampleLight</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



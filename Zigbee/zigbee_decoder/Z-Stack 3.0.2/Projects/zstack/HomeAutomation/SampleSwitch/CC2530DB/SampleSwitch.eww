<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleSwitch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SampleSwitch</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SampleSwitch</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SampleSwitch</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SampleSwitch</project>
        <configuration>EndDeviceEB - OTAClient</configuration>
      </member>
      <member>
        <project>SampleSwitch</project>
        <configuration>RouterEB - OTAClient</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



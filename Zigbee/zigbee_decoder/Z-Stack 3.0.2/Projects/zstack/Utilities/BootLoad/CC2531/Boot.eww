<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Boot.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Boot</project>
        <configuration>CC2531 Boot Loader</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



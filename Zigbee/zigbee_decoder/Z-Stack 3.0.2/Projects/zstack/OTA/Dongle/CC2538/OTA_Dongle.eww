<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\OTA_Dongle.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>OTA_Dongle</project>
        <configuration>Coordinator</configuration>
      </member>
      <member>
        <project>OTA_Dongle</project>
        <configuration>EndDevice</configuration>
      </member>
      <member>
        <project>OTA_Dongle</project>
        <configuration>Router</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



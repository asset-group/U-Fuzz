<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\OTA_Dongle.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>OTA_Dongle</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>OTA_Dongle</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>OTA_Dongle</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


